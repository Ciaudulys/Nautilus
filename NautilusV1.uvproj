# Keil uVision project NautilusV1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: NautilusV1 +hex
  c flags: Optim=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: D:\TI\TivaWare;.\UserLib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_TM4C123.s
  group app
    ./: main.c
  group RTX
    ./UserLib/: RTX_Conf_CM.c
  group libs
    D:/TI/TivaWare/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c sysctl.c sysexc.c systick.c ssi.c sw_crc.c timer.c uart.c udma.c usb.c watchdog.c
    ./UserLib/: board.c 23LCV1024.c 23LCV1024_hw.c ads1294r.c ads1294r_app.c ads1294r_hw.c AFE4490.c AFE4490_app.c AFE4490_TM4C123GH6PMI_hw.c data_structure.c Filtrai.c LSM330DLC.c LSM330DLC_app.c LSM330DLC_hw.c
    ./UserLib/SD_card/: ff.c MmcTm4c123g.c
